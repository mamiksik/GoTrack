## main/Kconfig
```kconfig
menu "GoTrack Config"

config DEVICE_NAME
    string "Device name"
     default "GoClimb - GoTack"
endmenu
```
